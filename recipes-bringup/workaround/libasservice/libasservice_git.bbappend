CXXFLAGS:append:sharp-m120 = " -DNO_SSL_DL"
