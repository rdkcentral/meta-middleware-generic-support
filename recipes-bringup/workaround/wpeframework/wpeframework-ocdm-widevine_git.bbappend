DEPENDS:remove = " widevinecdmi"
DEPENDS:append = " virtual/vendor-widevinecdmi"
