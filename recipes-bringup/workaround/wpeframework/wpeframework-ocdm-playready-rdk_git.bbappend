DEPENDS:remove = " playready-cdm-rdk"
DEPENDS:append = " virtual/vendor-playready-cdm-rdk"
