DEPENDS:remove += " playready-cdm-rdk playready-cdm-rdk-netflix "
DEPENDS:append += " virtual/vendor-playready-cdm-rdk "
