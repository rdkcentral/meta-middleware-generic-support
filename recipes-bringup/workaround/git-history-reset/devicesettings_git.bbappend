SRC_URI = "${RDKE_GITHUB_ROOT}/devicesettings;${RDKE_GITHUB_SRC_URI_SUFFIX};name=devicesettings"
