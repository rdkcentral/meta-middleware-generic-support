DEPENDS:remove += " virtual/vendor-secapi-netflix playready-cdm-rdk-netflix"
PARTNER_BRIDGE_FILE:sharp-m120="amlogic-PartnerBridge.js"
ENV_SETUP_FILE:sharp-m120="amlogic-env-setup.sh"
CONFIG_FILE:sharp-m120="config-sharp-m120.xml"
