RDEPENDS:${PN}:remove = " tvsettings-plugins "
