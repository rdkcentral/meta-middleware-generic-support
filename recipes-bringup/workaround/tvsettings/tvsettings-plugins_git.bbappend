INSANE_SKIP:${PN} += "dev-deps"
