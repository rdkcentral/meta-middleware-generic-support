DEPENDS += "openssl"
CFLAGS:append = " -DNO_SSL_DL"
