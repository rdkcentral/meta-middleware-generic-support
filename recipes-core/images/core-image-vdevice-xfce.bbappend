IMAGE_INSTALL:append = " packagegroup-middleware-layer-core-xfce "
RDEPENDS:remove:${PN} = "avbuffer videodecoder audiodecoder"
