DEPENDS:remove = " tvsettings-plugins "
