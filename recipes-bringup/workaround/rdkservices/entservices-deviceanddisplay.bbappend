PACKAGECONFIG:remove = " displayinfo "
