FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://0001-RDKEMW-4745-Add-patch-to-insert-encrypted-parsers.patch"
