FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://0001-DELIA-64727-Prealloc-secure-memory-before-decrypt.patch "
